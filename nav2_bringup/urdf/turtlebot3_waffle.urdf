Commit message: all base_footprint to base_link

File: nav2_bringup/urdf/turtlebot3_waffle.urdf (robot description, URDF)
Before this commit: robot turtlebot3_waffle, 13 links, 12 joints
Links:
- removed link base_footprint
Joints:
- joint base_joint: parent base_footprint -> base_link
